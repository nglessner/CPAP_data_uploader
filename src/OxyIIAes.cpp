// AES-128/ECB/PKCS7 implementation for the OxyII protocol.
//
// On ESP32 (UNIT_TEST not defined), delegates to mbedtls — already linked
// for HTTPS by SleepHQUploader. On the native test env, uses a self-contained
// AES-128 ECB reference implementation derived from the NIST FIPS-197
// standard. Public API in OxyIIAes.h is the same either way.

#include "OxyIIAes.h"

#include <cstring>

#ifndef UNIT_TEST
#include <mbedtls/aes.h>
#endif

namespace {

// PKCS7 pad: append (BLOCK_SIZE - len%BLOCK_SIZE) bytes, each equal to that
// count. Always adds at least one byte, even when the input is block-aligned.
size_t pkcs7Pad(const uint8_t* in, size_t inLen, uint8_t* out, size_t outCap) {
    using OxyIIAes::BLOCK_SIZE;
    uint8_t pad = static_cast<uint8_t>(BLOCK_SIZE - (inLen % BLOCK_SIZE));
    size_t total = inLen + pad;
    if (outCap < total) return 0;
    if (in && inLen) memcpy(out, in, inLen);
    for (size_t i = inLen; i < total; i++) out[i] = pad;
    return total;
}

// PKCS7 unpad: returns the unpadded length, or 0 if the trailing padding is
// invalid (last byte 0 or > 16, or the trailing run isn't constant).
size_t pkcs7Unpad(const uint8_t* in, size_t inLen) {
    using OxyIIAes::BLOCK_SIZE;
    if (inLen == 0 || inLen % BLOCK_SIZE != 0) return 0;
    uint8_t pad = in[inLen - 1];
    if (pad == 0 || pad > BLOCK_SIZE) return 0;
    if (pad > inLen) return 0;
    for (size_t i = inLen - pad; i < inLen; i++) {
        if (in[i] != pad) return 0;
    }
    return inLen - pad;
}

#ifdef UNIT_TEST
// ---------- Self-contained AES-128 ECB (FIPS-197) for the native test env.

constexpr size_t Nb = 4;   // block size in 32-bit words
constexpr size_t Nk = 4;   // key length in 32-bit words (AES-128)
constexpr size_t Nr = 10;  // number of rounds (AES-128)
constexpr size_t EXPANDED_KEY_BYTES = Nb * (Nr + 1) * 4;  // 176 bytes

const uint8_t kSbox[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};

const uint8_t kRsbox[256] = {
    0x52,0x09,0x6a,0xd5,0x30,0x36,0xa5,0x38,0xbf,0x40,0xa3,0x9e,0x81,0xf3,0xd7,0xfb,
    0x7c,0xe3,0x39,0x82,0x9b,0x2f,0xff,0x87,0x34,0x8e,0x43,0x44,0xc4,0xde,0xe9,0xcb,
    0x54,0x7b,0x94,0x32,0xa6,0xc2,0x23,0x3d,0xee,0x4c,0x95,0x0b,0x42,0xfa,0xc3,0x4e,
    0x08,0x2e,0xa1,0x66,0x28,0xd9,0x24,0xb2,0x76,0x5b,0xa2,0x49,0x6d,0x8b,0xd1,0x25,
    0x72,0xf8,0xf6,0x64,0x86,0x68,0x98,0x16,0xd4,0xa4,0x5c,0xcc,0x5d,0x65,0xb6,0x92,
    0x6c,0x70,0x48,0x50,0xfd,0xed,0xb9,0xda,0x5e,0x15,0x46,0x57,0xa7,0x8d,0x9d,0x84,
    0x90,0xd8,0xab,0x00,0x8c,0xbc,0xd3,0x0a,0xf7,0xe4,0x58,0x05,0xb8,0xb3,0x45,0x06,
    0xd0,0x2c,0x1e,0x8f,0xca,0x3f,0x0f,0x02,0xc1,0xaf,0xbd,0x03,0x01,0x13,0x8a,0x6b,
    0x3a,0x91,0x11,0x41,0x4f,0x67,0xdc,0xea,0x97,0xf2,0xcf,0xce,0xf0,0xb4,0xe6,0x73,
    0x96,0xac,0x74,0x22,0xe7,0xad,0x35,0x85,0xe2,0xf9,0x37,0xe8,0x1c,0x75,0xdf,0x6e,
    0x47,0xf1,0x1a,0x71,0x1d,0x29,0xc5,0x89,0x6f,0xb7,0x62,0x0e,0xaa,0x18,0xbe,0x1b,
    0xfc,0x56,0x3e,0x4b,0xc6,0xd2,0x79,0x20,0x9a,0xdb,0xc0,0xfe,0x78,0xcd,0x5a,0xf4,
    0x1f,0xdd,0xa8,0x33,0x88,0x07,0xc7,0x31,0xb1,0x12,0x10,0x59,0x27,0x80,0xec,0x5f,
    0x60,0x51,0x7f,0xa9,0x19,0xb5,0x4a,0x0d,0x2d,0xe5,0x7a,0x9f,0x93,0xc9,0x9c,0xef,
    0xa0,0xe0,0x3b,0x4d,0xae,0x2a,0xf5,0xb0,0xc8,0xeb,0xbb,0x3c,0x83,0x53,0x99,0x61,
    0x17,0x2b,0x04,0x7e,0xba,0x77,0xd6,0x26,0xe1,0x69,0x14,0x63,0x55,0x21,0x0c,0x7d
};

const uint8_t kRcon[11] = {
    0x00, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1b, 0x36
};

void keyExpansion(const uint8_t* key, uint8_t* roundKeys) {
    uint8_t tmp[4];
    memcpy(roundKeys, key, Nk * 4);

    for (size_t i = Nk; i < Nb * (Nr + 1); i++) {
        memcpy(tmp, roundKeys + (i - 1) * 4, 4);
        if (i % Nk == 0) {
            // RotWord
            uint8_t t = tmp[0]; tmp[0] = tmp[1]; tmp[1] = tmp[2]; tmp[2] = tmp[3]; tmp[3] = t;
            // SubWord
            for (int j = 0; j < 4; j++) tmp[j] = kSbox[tmp[j]];
            // Rcon
            tmp[0] ^= kRcon[i / Nk];
        }
        for (int j = 0; j < 4; j++) {
            roundKeys[i * 4 + j] = roundKeys[(i - Nk) * 4 + j] ^ tmp[j];
        }
    }
}

void addRoundKey(uint8_t state[16], const uint8_t* roundKey) {
    for (int i = 0; i < 16; i++) state[i] ^= roundKey[i];
}

void subBytes(uint8_t state[16])    { for (int i = 0; i < 16; i++) state[i] = kSbox[state[i]]; }
void invSubBytes(uint8_t state[16]) { for (int i = 0; i < 16; i++) state[i] = kRsbox[state[i]]; }

void shiftRows(uint8_t s[16]) {
    uint8_t t;
    // row 1
    t = s[1]; s[1] = s[5]; s[5] = s[9]; s[9] = s[13]; s[13] = t;
    // row 2
    t = s[2]; s[2] = s[10]; s[10] = t;
    t = s[6]; s[6] = s[14]; s[14] = t;
    // row 3
    t = s[15]; s[15] = s[11]; s[11] = s[7]; s[7] = s[3]; s[3] = t;
}

void invShiftRows(uint8_t s[16]) {
    uint8_t t;
    // row 1
    t = s[13]; s[13] = s[9]; s[9] = s[5]; s[5] = s[1]; s[1] = t;
    // row 2
    t = s[2]; s[2] = s[10]; s[10] = t;
    t = s[6]; s[6] = s[14]; s[14] = t;
    // row 3
    t = s[3]; s[3] = s[7]; s[7] = s[11]; s[11] = s[15]; s[15] = t;
}

uint8_t xtime(uint8_t x) { return static_cast<uint8_t>((x << 1) ^ ((x >> 7) ? 0x1b : 0x00)); }

void mixColumns(uint8_t s[16]) {
    for (int c = 0; c < 4; c++) {
        uint8_t a0 = s[c*4 + 0], a1 = s[c*4 + 1], a2 = s[c*4 + 2], a3 = s[c*4 + 3];
        uint8_t t = a0 ^ a1 ^ a2 ^ a3;
        s[c*4 + 0] ^= t ^ xtime(a0 ^ a1);
        s[c*4 + 1] ^= t ^ xtime(a1 ^ a2);
        s[c*4 + 2] ^= t ^ xtime(a2 ^ a3);
        s[c*4 + 3] ^= t ^ xtime(a3 ^ a0);
    }
}

uint8_t gmul(uint8_t a, uint8_t b) {
    uint8_t p = 0;
    for (int i = 0; i < 8; i++) {
        if (b & 1) p ^= a;
        uint8_t hi = a & 0x80;
        a <<= 1;
        if (hi) a ^= 0x1b;
        b >>= 1;
    }
    return p;
}

void invMixColumns(uint8_t s[16]) {
    for (int c = 0; c < 4; c++) {
        uint8_t a0 = s[c*4 + 0], a1 = s[c*4 + 1], a2 = s[c*4 + 2], a3 = s[c*4 + 3];
        s[c*4 + 0] = gmul(a0, 0x0e) ^ gmul(a1, 0x0b) ^ gmul(a2, 0x0d) ^ gmul(a3, 0x09);
        s[c*4 + 1] = gmul(a0, 0x09) ^ gmul(a1, 0x0e) ^ gmul(a2, 0x0b) ^ gmul(a3, 0x0d);
        s[c*4 + 2] = gmul(a0, 0x0d) ^ gmul(a1, 0x09) ^ gmul(a2, 0x0e) ^ gmul(a3, 0x0b);
        s[c*4 + 3] = gmul(a0, 0x0b) ^ gmul(a1, 0x0d) ^ gmul(a2, 0x09) ^ gmul(a3, 0x0e);
    }
}

void aesEncryptBlock(const uint8_t in[16], const uint8_t* roundKeys, uint8_t out[16]) {
    uint8_t state[16];
    memcpy(state, in, 16);
    addRoundKey(state, roundKeys);
    for (size_t round = 1; round < Nr; round++) {
        subBytes(state);
        shiftRows(state);
        mixColumns(state);
        addRoundKey(state, roundKeys + round * 16);
    }
    subBytes(state);
    shiftRows(state);
    addRoundKey(state, roundKeys + Nr * 16);
    memcpy(out, state, 16);
}

void aesDecryptBlock(const uint8_t in[16], const uint8_t* roundKeys, uint8_t out[16]) {
    uint8_t state[16];
    memcpy(state, in, 16);
    addRoundKey(state, roundKeys + Nr * 16);
    for (size_t round = Nr - 1; round > 0; round--) {
        invShiftRows(state);
        invSubBytes(state);
        addRoundKey(state, roundKeys + round * 16);
        invMixColumns(state);
    }
    invShiftRows(state);
    invSubBytes(state);
    addRoundKey(state, roundKeys);
    memcpy(out, state, 16);
}
#endif  // UNIT_TEST

}  // namespace

namespace OxyIIAes {

size_t encryptEcbPkcs7(const uint8_t* plaintext, size_t plaintextLen,
                       const uint8_t key[KEY_SIZE],
                       uint8_t* out, size_t outCap) {
    if (!key || !out) return 0;
    // Pad in place into out[]
    size_t padded = pkcs7Pad(plaintext, plaintextLen, out, outCap);
    if (padded == 0) return 0;

#ifdef UNIT_TEST
    uint8_t roundKeys[EXPANDED_KEY_BYTES];
    keyExpansion(key, roundKeys);
    for (size_t off = 0; off < padded; off += BLOCK_SIZE) {
        aesEncryptBlock(out + off, roundKeys, out + off);
    }
#else
    mbedtls_aes_context ctx;
    mbedtls_aes_init(&ctx);
    if (mbedtls_aes_setkey_enc(&ctx, key, 128) != 0) {
        mbedtls_aes_free(&ctx);
        return 0;
    }
    for (size_t off = 0; off < padded; off += BLOCK_SIZE) {
        if (mbedtls_aes_crypt_ecb(&ctx, MBEDTLS_AES_ENCRYPT, out + off, out + off) != 0) {
            mbedtls_aes_free(&ctx);
            return 0;
        }
    }
    mbedtls_aes_free(&ctx);
#endif

    return padded;
}

size_t decryptEcbPkcs7(const uint8_t* ciphertext, size_t ciphertextLen,
                       const uint8_t key[KEY_SIZE],
                       uint8_t* out, size_t outCap) {
    if (!key || !ciphertext || !out) return 0;
    if (ciphertextLen == 0 || ciphertextLen % BLOCK_SIZE != 0) return 0;
    if (outCap < ciphertextLen) return 0;

#ifdef UNIT_TEST
    uint8_t roundKeys[EXPANDED_KEY_BYTES];
    keyExpansion(key, roundKeys);
    for (size_t off = 0; off < ciphertextLen; off += BLOCK_SIZE) {
        aesDecryptBlock(ciphertext + off, roundKeys, out + off);
    }
#else
    mbedtls_aes_context ctx;
    mbedtls_aes_init(&ctx);
    if (mbedtls_aes_setkey_dec(&ctx, key, 128) != 0) {
        mbedtls_aes_free(&ctx);
        return 0;
    }
    for (size_t off = 0; off < ciphertextLen; off += BLOCK_SIZE) {
        if (mbedtls_aes_crypt_ecb(&ctx, MBEDTLS_AES_DECRYPT, ciphertext + off, out + off) != 0) {
            mbedtls_aes_free(&ctx);
            return 0;
        }
    }
    mbedtls_aes_free(&ctx);
#endif

    size_t unpadded = pkcs7Unpad(out, ciphertextLen);
    if (unpadded == 0) return 0;
    return unpadded;
}

}  // namespace OxyIIAes
